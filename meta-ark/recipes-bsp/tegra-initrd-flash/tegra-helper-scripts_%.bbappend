# Applied to native helpers copied into the flash bundle, and SDK/target variants.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-initrd-flash-preserve-nested-usb-device-path.patch"
